# Repository asahi-13/Noraneko

## KiCad design noraneko42c/v1.0/pcb/noraneko42c.kicad_pcb

Parts:
C1, C2, C4, C6, C7, C8, C9, C10, C11, C14: 100n; C_0402_1005Metric
C3, C5: 1u; C_0402_1005Metric
C12, C13: 20p; C_0402_1005Metric
C15, C16: 10u; C_0402_1005Metric
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34, D35, D36, D37, D38, D39, D40, D41, D42: D; 1N4148W; LCSC C81598
D44: RED; LED_0402_1005Metric
J1: 217179-0001; Connector_USB-C-Receptacle_SMT_12-Pin_MidMount_Simple
LED1, LED2, LED3, LED4, LED5, LED6, LED7, LED8, LED9, LED10, LED11, LED12, LED13, LED14, LED15, LED16, LED17, LED18, LED19, LED20, LED21, LED22, LED23, LED24, LED25, LED26, LED27, LED28, LED29, LED30, LED31, LED32, LED33, LED34, LED35, LED36, LED37, LED38, LED39, LED40, LED41, LED42: SK6812MINI-E
Q1: BSS138; SOT-23
R4, R7, R11: 5.1k; R_0402_1005Metric
R5, R6: 27.4; R_0402_1005Metric
R8, R10: 1k; R_0402_1005Metric
R9, R12, R13: 10k; R_0402_1005Metric
RESET1: SW_Push; SW_Push_1P1T_NO_Vertical_Wuerth_434133025816
SW1, SW2, SW3, SW4, SW5, SW6, SW7, SW8, SW9, SW10, SW11, SW12, SW13, SW14, SW15, SW16, SW17, SW18, SW19, SW20, SW21, SW22, SW23, SW24, SW25, SW26, SW27, SW28, SW29, SW30, SW31, SW32, SW33, SW34, SW35, SW36, SW37, SW38, SW39, SW40, SW41, SW42: SW_Push; Choc_v2_Hotswap_1u
SW43: SW_Push; SW_Push_1P1T_NO_Vertical_Wuerth_434133025816
U2: RP2040; QFN-56-1EP_7x7mm_P0.4mm_EP3.2x3.2mm; MPN C2040
U3: W25Q32JVS; WSON-8-1EP_6x5mm_P1.27mm_EP3.4x4.3mm
U4: CH213K; Package_SOT-23
U5: AMS1117-3.3; Package_SOT-89-3
Y1: 12M; Crystal_SMD_3225-4Pin_3.2x2.5mm_HandSoldering

Connections:
+1V1: C1.1, C2.1, C3.1, U2.23 (DVDD), U2.45 (VREG_VOUT), U2.50 (DVDD)
+3V3: C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C14.1, C16.1, Q1.1 (G), R9.2, R11.2, R12.2, U2.1 (IOVDD), U2.10 (IOVDD), U2.22 (IOVDD), U2.33 (IOVDD), U2.42 (IOVDD), U2.43 (ADC_AVDD), U2.44 (VREG_IN), U2.48 (USB_VDD), U2.49 (IOVDD), U3.8 (VCC), U5.2 (VO)
+5V: C15.1, LED1.1 (VDD), LED2.1 (VDD), LED3.1 (VDD), LED4.1 (VDD), LED5.1 (VDD), LED6.1 (VDD), LED7.1 (VDD), LED8.1 (VDD), LED9.1 (VDD), LED10.1 (VDD), LED11.1 (VDD), LED12.1 (VDD), LED13.1 (VDD), LED14.1 (VDD), LED15.1 (VDD), LED16.1 (VDD), LED17.1 (VDD), LED18.1 (VDD), LED19.1 (VDD), LED20.1 (VDD), LED21.1 (VDD), LED22.1 (VDD), LED23.1 (VDD), LED24.1 (VDD), LED25.1 (VDD), LED26.1 (VDD), LED27.1 (VDD), LED28.1 (VDD), LED29.1 (VDD), LED30.1 (VDD), LED31.1 (VDD), LED32.1 (VDD), LED33.1 (VDD), LED34.1 (VDD), LED35.1 (VDD), LED36.1 (VDD), LED37.1 (VDD), LED38.1 (VDD), LED39.1 (VDD), LED40.1 (VDD), LED41.1 (VDD), LED42.1 (VDD), R13.2, U4.2 (VO-), U5.3 (VI)
/BOOTSEL: R10.1, SW43.2
/QSPI_CLK: U2.52 (QSPI_SCLK), U3.6 (CLK)
/QSPI_SD0: U2.53 (QSPI_SD0), U3.5 (DI(IO0))
/QSPI_SD1: U2.55 (QSPI_SD1), U3.2 (DO(IO1))
/QSPI_SD2: U2.54 (QSPI_SD2), U3.3 (IO2)
/QSPI_SD3: U2.51 (QSPI_SD3), U3.7 (IO3)
/QSPI_SS: R9.1, R10.2, U2.56 (QSPI_SS), U3.1 (~CS)
/USB+: J1.3 (D+), R6.1
/USB-: J1.2 (D-), R5.1
/USB_DN: R5.2, U2.46 (USB_DM)
/USB_DP: R6.2, U2.47 (USB_DP)
/XIN: C12.2, U2.20 (XIN), Y1.1
/XOUT: R8.1, U2.21 (XOUT)
COL0: SW1.1, SW13.1, SW25.1, SW37.1, U2.41 (GPIO29_ADC3)
COL1: SW2.1, SW14.1, SW26.1, SW38.1, U2.40 (GPIO28_ADC2)
COL2: SW3.1, SW15.1, SW27.1, SW39.1, U2.39 (GPIO27_ADC1)
COL3: SW4.1, SW16.1, SW28.1, SW40.1, U2.38 (GPIO26_ADC0)
COL4: SW5.1, SW17.1, SW29.1, SW41.1, U2.37 (GPIO25)
COL5: SW6.1, SW18.1, SW30.1, SW42.1, U2.36 (GPIO24)
COL6: SW7.1, SW19.1, SW31.1, U2.6 (GPIO4)
COL7: SW8.1, SW20.1, SW32.1, U2.7 (GPIO5)
COL8: SW9.1, SW21.1, SW33.1, U2.8 (GPIO6)
COL9: SW10.1, SW22.1, SW34.1, U2.11 (GPIO8)
COL10: SW11.1, SW23.1, SW35.1, U2.12 (GPIO9)
COL11: SW12.1, SW24.1, SW36.1, U2.13 (GPIO10)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.1, C13.1, C14.2, C15.2, C16.2, D44.1 (K), J1.4 (GND), LED1.3 (VSS), LED2.3 (VSS), LED3.3 (VSS), LED4.3 (VSS), LED5.3 (VSS), LED6.3 (VSS), LED7.3 (VSS), LED8.3 (VSS), LED9.3 (VSS), LED10.3 (VSS), LED11.3 (VSS), LED12.3 (VSS), LED13.3 (VSS), LED14.3 (VSS), LED15.3 (VSS), LED16.3 (VSS), LED17.3 (VSS), LED18.3 (VSS), LED19.3 (VSS), LED20.3 (VSS), LED21.3 (VSS), LED22.3 (VSS), LED23.3 (VSS), LED24.3 (VSS), LED25.3 (VSS), LED26.3 (VSS), LED27.3 (VSS), LED28.3 (VSS), LED29.3 (VSS), LED30.3 (VSS), LED31.3 (VSS), LED32.3 (VSS), LED33.3 (VSS), LED34.3 (VSS), LED35.3 (VSS), LED36.3 (VSS), LED37.3 (VSS), LED38.3 (VSS), LED39.3 (VSS), LED40.3 (VSS), LED41.3 (VSS), LED42.3 (VSS), R4.2, R7.2, RESET1.2, SW43.1, U2.19 (TESTEN), U2.57 (GND), U3.4 (GND), U4.1 (GND), U5.1 (GND), Y1.2, Y1.4
LED_High_V: LED1.4 (DIN), Q1.3 (D), R13.1
LED_Low_V: Q1.2 (S), R12.1, U2.27 (GPIO16)
unnamed: C13.2, R8.2, Y1.3
unnamed: D1.2 (A), SW1.2
unnamed: D2.2 (A), SW2.2
unnamed: D3.2 (A), SW3.2
unnamed: D4.2 (A), SW4.2
unnamed: D5.2 (A), SW5.2
unnamed: D6.2 (A), SW6.2
unnamed: D7.2 (A), SW7.2
unnamed: D8.2 (A), SW8.2
unnamed: D9.2 (A), SW9.2
unnamed: D10.2 (A), SW10.2
unnamed: D11.2 (A), SW11.2
unnamed: D12.2 (A), SW12.2
unnamed: D13.2 (A), SW13.2
unnamed: D14.2 (A), SW14.2
unnamed: D15.2 (A), SW15.2
unnamed: D16.2 (A), SW16.2
unnamed: D17.2 (A), SW17.2
unnamed: D18.2 (A), SW18.2
unnamed: D19.2 (A), SW19.2
unnamed: D20.2 (A), SW20.2
unnamed: D21.2 (A), SW21.2
unnamed: D22.2 (A), SW22.2
unnamed: D23.2 (A), SW23.2
unnamed: D24.2 (A), SW24.2
unnamed: D25.2 (A), SW25.2
unnamed: D26.2 (A), SW26.2
unnamed: D27.2 (A), SW27.2
unnamed: D28.2 (A), SW28.2
unnamed: D29.2 (A), SW29.2
unnamed: D30.2 (A), SW30.2
unnamed: D31.2 (A), SW31.2
unnamed: D32.2 (A), SW32.2
unnamed: D33.2 (A), SW33.2
unnamed: D34.2 (A), SW34.2
unnamed: D35.2 (A), SW35.2
unnamed: D36.2 (A), SW36.2
unnamed: D37.2 (A), SW37.2
unnamed: D38.2 (A), SW38.2
unnamed: D39.2 (A), SW39.2
unnamed: D40.2 (A), SW40.2
unnamed: D41.2 (A), SW41.2
unnamed: D42.2 (A), SW42.2
unnamed: D44.2 (A), R11.1
unnamed: J1.5 (CC1), R7.1
unnamed: J1.6 (CC2), R4.1
unnamed: LED1.2 (DOUT), LED2.4 (DIN)
unnamed: LED2.2 (DOUT), LED3.4 (DIN)
unnamed: LED3.2 (DOUT), LED4.4 (DIN)
unnamed: LED4.2 (DOUT), LED5.4 (DIN)
unnamed: LED5.2 (DOUT), LED6.4 (DIN)
unnamed: LED6.2 (DOUT), LED7.4 (DIN)
unnamed: LED7.2 (DOUT), LED8.4 (DIN)
unnamed: LED8.2 (DOUT), LED9.4 (DIN)
unnamed: LED9.2 (DOUT), LED10.4 (DIN)
unnamed: LED10.2 (DOUT), LED11.4 (DIN)
unnamed: LED11.2 (DOUT), LED12.4 (DIN)
unnamed: LED12.2 (DOUT), LED13.4 (DIN)
unnamed: LED13.2 (DOUT), LED14.4 (DIN)
unnamed: LED14.2 (DOUT), LED15.4 (DIN)
unnamed: LED15.2 (DOUT), LED16.4 (DIN)
unnamed: LED16.2 (DOUT), LED17.4 (DIN)
unnamed: LED17.2 (DOUT), LED18.4 (DIN)
unnamed: LED18.2 (DOUT), LED19.4 (DIN)
unnamed: LED19.2 (DOUT), LED20.4 (DIN)
unnamed: LED20.2 (DOUT), LED21.4 (DIN)
unnamed: LED21.2 (DOUT), LED22.4 (DIN)
unnamed: LED22.2 (DOUT), LED23.4 (DIN)
unnamed: LED23.2 (DOUT), LED24.4 (DIN)
unnamed: LED24.2 (DOUT), LED25.4 (DIN)
unnamed: LED25.2 (DOUT), LED26.4 (DIN)
unnamed: LED26.2 (DOUT), LED27.4 (DIN)
unnamed: LED27.2 (DOUT), LED28.4 (DIN)
unnamed: LED28.2 (DOUT), LED29.4 (DIN)
unnamed: LED29.2 (DOUT), LED30.4 (DIN)
unnamed: LED30.2 (DOUT), LED31.4 (DIN)
unnamed: LED31.2 (DOUT), LED32.4 (DIN)
unnamed: LED32.2 (DOUT), LED33.4 (DIN)
unnamed: LED33.2 (DOUT), LED34.4 (DIN)
unnamed: LED34.2 (DOUT), LED35.4 (DIN)
unnamed: LED35.2 (DOUT), LED36.4 (DIN)
unnamed: LED36.2 (DOUT), LED37.4 (DIN)
unnamed: LED37.2 (DOUT), LED38.4 (DIN)
unnamed: LED38.2 (DOUT), LED39.4 (DIN)
unnamed: LED39.2 (DOUT), LED40.4 (DIN)
unnamed: LED40.2 (DOUT), LED41.4 (DIN)
unnamed: LED41.2 (DOUT), LED42.4 (DIN)
ROW0: D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), D9.1 (K), D10.1 (K), D11.1 (K), D12.1 (K), U2.2 (GPIO0)
ROW1: D13.1 (K), D14.1 (K), D15.1 (K), D16.1 (K), D17.1 (K), D18.1 (K), D19.1 (K), D20.1 (K), D21.1 (K), D22.1 (K), D23.1 (K), D24.1 (K), U2.3 (GPIO1)
ROW2: D25.1 (K), D26.1 (K), D27.1 (K), D28.1 (K), D29.1 (K), D30.1 (K), D31.1 (K), D32.1 (K), D33.1 (K), D34.1 (K), D35.1 (K), D36.1 (K), U2.4 (GPIO2)
ROW3: D37.1 (K), D38.1 (K), D39.1 (K), D40.1 (K), D41.1 (K), D42.1 (K), U2.5 (GPIO3)
VBUS: J1.1 (VBUS), U4.3 (VI+)
reset: RESET1.1, U2.26 (RUN)

Notes on the sheet:
make sure C5(1u) is close to pin 44 of RP2040
make sure R5 and R6 are close to RP2040
レベルシフト回路
LED
Flash
Power
Reset
Oscillator
make sure C3(1u) is close to pin 45 of RP2040
MCU
Key Switches
USB & Power

Board: 2 copper layers, 269.7 x 112.2 mm, 162 parts (162 on the bottom side), 124 nets.
